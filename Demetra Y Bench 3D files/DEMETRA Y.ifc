Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:50:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:50:40 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{8A6733BA-2089-4A57-8C38-E578D3076B6F}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:50:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:50:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:50:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR161 - WITHOUT LEVELLING - VERDE ALPI, Panca DEMETRA Y:0PAAR161 - WITHOUT LEVELLING - VERDE ALPI:176435
In: 0 - Piano Terra
Type - Material: VERDE ALPI
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DEMETRA Y
Type - Dati identità - BIM Name: DEMETRA Y SENZA LIVELLAMENTO; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR161; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0PAAR161 - WITHOUT LEVELLING - VERDE ALPI; URL Eng: https://www.bellitalia.net/en/products/benches/demetra-y/; URL Ita: https://www.bellitalia.net/prodotti/panchine/demetra-y/
Type - Dimensioni - Dimensions: 1705 mm x 1764 mm x 480 mm
Type - Generale - Accessori: Supplemento per una striscia led e alimentatore; Accessories: Supplement for a led strip and power supply; Descrizione Tecnica Famiglia: "Panca modulare mod. “DEMETRA” Y costituita da una seduta monolitica. La forma geometrica in planimetria della pianta è similare alla lettera Y, simmetrica sull'asse planimetrico principale."; Descrizione Tecnica per Codice: PANCA DEMETRA Y SENZA LIVELLAMENTO IN VERDE ALPI SABBIATO CON PIANO DI SEDUTA BOCCIARDATO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Modular bench mod. “DEMETRA” Y consisting of a monolithic seat. The geometric shape in the planimetry of the plant is similar to the letter Y, symmetrical on the main planimetric axis."; Technical Description for Article: DEMETRA Y WITHOUT LEVELLING SYSTEM BENCH IN GREEN ALPS SANDBLASTED WITH BUSH-HAMMERED SEAT SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; MATERIALE SEDUTA: VERDE ALPI; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone
Type - Meccanica - Weight ( kg): 1884 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR161 - WITHOUT LEVELLING - VERDE ALPI
Altro - Famiglia: Panca DEMETRA Y: 0PAAR161 - WITHOUT LEVELLING - VERDE ALPI; Famiglia e tipo: Panca DEMETRA Y: 0PAAR161 - WITHOUT LEVELLING - VERDE ALPI; ID tipo: Panca DEMETRA Y: 0PAAR161 - WITHOUT LEVELLING - VERDE ALPI; Tipo: Panca DEMETRA Y: 0PAAR161 - WITHOUT LEVELLING - VERDE ALPI
Dimensioni - Area: 4.82205 m2; Volume: 0.765816 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
